# Copyright (c) 2020 LG Electronics, Inc.
# Copyright (c) 2022 Wind River Systems, Inc.

FILES:${PN}-dev += "${datadir}/orocos_kdl/cmake/*.cmake"

inherit ros_insane_dev_so
